Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-09-18T11:50:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 18 11:50:10 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\6924409f-4c87-4395-b9e2-1553f50bc15c\dbb85d32-0c62-4a62-91da-03b0fc8bf341\ifc * Database version: 5507 * Database creation date: Mon Sep 18 11:50:09 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 18 11:50:09 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 18 11:50:09 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12423610_USA_EVS7670_OBSWMATT:30767051_USA_12423610_EVS7670_OBSWMATT, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 30767051_USA_12423610_EVS7670_OBSWMATT
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 30767051_USA_12423610_EVS7670_OBSWMATT
Type - Pset_ProvisionForVoid - Width: 757 mm; Height: 275 mm; Depth: 608 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcDistributionPort, Port_351887
Description: Flow; FlowDirection: SOURCEANDSINK
